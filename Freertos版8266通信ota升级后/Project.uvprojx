# Keil uVision project Project.uvprojx, settings and files
target Target_1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\CMSIS;.\Library\inc;.\User;.\Freertos\Source\include;.\Freertos\Source\portable;.\Hardware;.\OLED;.\W25Qxx
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h freertos_demo.c freertos_demo.h
  group Libraty
    ./Library/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ./Library/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ./CMSIS/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Freertos
    ./Freertos/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./Freertos/Source/include/: FreeRTOSConfig.h
    ./Freertos/Source/portable/: heap_4.c port.c
  group Hardware
    ./Hardware/: Usart.c Usart.h esp8266.c esp8266.h delay.c delay.h LED.c LED.h Servo.c Servo.h DHT11.c DHT11.h
    ./HardWare/: IWDG.c IDWG.h
  group OLED
    ./OLED/: OLED.c OLED.h OLED_Data.c OLED_Data.h
  group W25Qxx
    ./W25Qxx/: MySPI.c MySPI.h W25Q64.c W25Q64.h W25Q64_Ins.h
